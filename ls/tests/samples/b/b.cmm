PRINT "This is B"
